# IAR project BasicRF.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Components/utils; Components/common; Components/basicrf; Components/targets/interface; Components/assembly; Components/common/cc8051; Components/targets/srf05_soc; Components/radios/cc2530; Src
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2540F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group application
    Src/: main.c
  group basicrf
    Components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    Components/common/cc8051/: hal_cc8051.h
    Components/common/: hal_defs.h hal_int.c hal_types.h
    Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group hal/rf
    Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    Components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c
  group hal/srf05_soc
    Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group untililtes
    Components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
